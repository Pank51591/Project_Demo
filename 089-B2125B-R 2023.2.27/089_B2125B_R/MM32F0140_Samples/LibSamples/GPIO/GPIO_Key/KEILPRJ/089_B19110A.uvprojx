# Keil uVision project 089_B19110A.uvprojx, settings and files
target MM32Series (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F0144C6P MindMotion
  pack: MindMotion.MM32F0140_DFP.0.0.5
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=177
  c include: ..\..\..\..\..\Device\MM32F0140\Include;..\..\..\..\..\Device\MM32F0140\HAL_Lib\Inc;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\USER;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE;..\HARDWARE\TIM;..\HARDWARE\LED_RF;..\HARDWARE\RF_A7325;..\HARDWARE\Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ../../../../../Device/MM32F0140/Source/: system_mm32f0140.c
    ../../../../../Device/MM32F0140/Source/KEIL_StartAsm/: startup_mm32f0140_keil.s
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIM/: tim1_interrupt.c
    ../HARDWARE/LED_RF/: LED_RF.c
    ../HARDWARE/RF_A7325/: RF_A7325.c
    ../HARDWARE/Test/: test.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
  group HAL_Lib
    ../../../../../Device/MM32F0140/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_flexcan.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_sqrt.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
