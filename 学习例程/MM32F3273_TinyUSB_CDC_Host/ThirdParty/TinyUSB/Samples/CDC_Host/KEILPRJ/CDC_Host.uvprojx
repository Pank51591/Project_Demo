# Keil uVision project CDC_Host.uvprojx, settings and files
target MM32Series (6150000::V6.15::ARMCLANG)
  device: MM32F3273G8P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.5
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,TUP_USBIP_OHCI
  c include: ..\..\..\..\..\Device\CMSIS\KEIL_Core;..\..\..\..\..\Device\MM32F327x\Include;..\..\..\..\..\Device\MM32F327x\HAL_Lib\Inc;..\USER;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED;..\..\..\tinyusb\src;..\..\..\tinyusb\src\class\cdc;..\..\..\tinyusb\src\class\hid;..\..\..\tinyusb\src\class\msc;..\..\..\tinyusb\src\common;..\..\..\tinyusb\src\host;..\..\..\tinyusb\src\device;..\..\..\tinyusb\lib\fatfs\source;..\..\..\tinyusb\lib\embedded-cli
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../../../../Device/MM32F327x/Source/: system_mm32f327x.c
    ../../../../../Device/MM32F327x/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c tinyusb_host_cdc.c tuh_hcd_port.c cdc_app.c
  group HAL_Lib
    ../../../../../Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c hal_usb.c
  group TinyUSB
    ../../../tinyusb/src/: tusb.c
    ../../../tinyusb/src/common/: tusb_fifo.c
    ../../../tinyusb/src/host/: hub.c usbh.c
    ../../../tinyusb/src/class/cdc/: cdc_host.c cdc_rndis_host.c
