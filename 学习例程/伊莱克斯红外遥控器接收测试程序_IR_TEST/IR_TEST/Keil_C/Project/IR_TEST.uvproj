# Keil uVision project IR_TEST.uvproj, settings and files
target <IR_TEST> (MCS-51)
  device: SC95F8617B SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: IR_TEST +hex
  c flags: Optimize=9
  c define: SC95F8x1xB
  c include: ..\FWLib\SC95F_Lib\inc;..\User;..\Project
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c SysFunVarDefine.c
    ./: ir.c ir.h
  group FWLib
    ../FWLib/SC95F_Lib/src/: sc95f_timer0.c sc95f_usci0.c sc95f_int.c sc95f_gpio.c
  group Startup
    ./: STARTUP.A51
