# Keil uVision project STM32F103-USB-CDC-CMSIS.uvprojx, settings and files
target STM32F103-USB-CDC-CMSIS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103-USB-CDC-CMSIS
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./Src/: main.c usblib.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
