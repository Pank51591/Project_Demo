# Keil uVision project sys.uvprojx, settings and files
target Load (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BAT32G135GE32FP Cmsemicon
  pack: Cmsemicon.BAT32G135.0.2.1
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: IceMachine_Dispay +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\code\drv;..\code\MCU;..\code\SysFile;..\code\User;..\code\win;..\Library\Driver\inc;..\Library\CMSIS\Include;..\Library\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../Library/Device/Source/: system_BAT32G135.c
    ../Library/Device/Source/ARM/: startup_BAT32G135.s
  group Library
    ../Library/Driver/src/: adc.c gpio.c sci.c flash.c wdt.c retarget.c intp.c
  group sysfile
    ../code/SysFile/: AppUart.c delay.c fifo.c IOInit.c sys_clock.c system.c Task.c window.c KeyScan.c
  group drv
    ../code/drv/: drvLCD1602.c
  group Win
    ../code/win/: Windesktop.c WinOreration.c WinData.c WinService.c WinLEDLevel.c WinTypeSize.c WinDispenseCnt.c WinDispenseCnt.h
  group User
    ../code/User/: main.c appsystem.c Displayboard.c SaveData.c sim_eeprom.c
software components: CMSIS:CORE 5.5.0
