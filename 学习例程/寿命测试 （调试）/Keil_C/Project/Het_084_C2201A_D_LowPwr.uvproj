# Keil uVision project Het_084_C2201A_D_LowPwr.uvproj, settings and files
target <Het_084_C2201A_D_LowPwr> (MCS-51)
  device: SC95F8617B SC95Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(32000000)
  output: Het_084_C2201A_D_LowPwr +hex
  c flags: Optimize=9
  c define: SC95F8x1xB
  c include: ..\FWLib\SC95F_Lib\inc;..\User;..\User\Funtion;..\SOC_DebugTouchKey_Lib;..\SOC_DebugTouchKey_Lib;..\IAP_Lib
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c SysFunVarDefine.c SC_System.h SR_EEPROM.c
    ../User/Funtion/: ADC_Process.c Burner_Process.c Buzzer_Process.c Key_Process.c Output_Process.c Sleep_Process.c Time_Process.c Lifetest.c
    ../IAP_Lib/: SC95FXX1XB_IAP_lib_V1.0.0.LIB
  group Drivers
    ../Drivers/TKDriver/C/: SC95F8X1XB_HighSensitive_lib_T1LowPower_L_V2.1.0.LIB TKDriver.C
  group FWLib
    ../FWLib/SC95F_Lib/src/: sc95f_gpio.c sc95f_option.c sc95f_int.c sc95f_wdt.c sc95f_pwm.c sc95f_timer1.c sc95f_timer0.c sc95f_adc.c
  group Startup
    ./: STARTUP.A51
