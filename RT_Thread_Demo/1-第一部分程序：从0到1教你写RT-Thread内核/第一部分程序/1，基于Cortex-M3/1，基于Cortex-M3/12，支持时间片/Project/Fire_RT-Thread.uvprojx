# Keil uVision project Fire_RT-Thread.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: YH-RT-Thread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\rtthread\3.0.3\bsp;..\rtthread\3.0.3\components\finsh;..\rtthread\3.0.3\include;..\rtthread\3.0.3\include\libc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c rtconfig.h
  group rtt/ports
    ../rtthread/3.0.3/libcpu/arm/cortex-m3/: context_rvds.s cpuport.c
  group rtt/source
    ../rtthread/3.0.3/src/: scheduler.c thread.c object.c kservice.c idle.c irq.c clock.c timer.c
  group doc
    ../Doc/: readm.txt
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
