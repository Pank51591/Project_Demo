# Keil uVision project iSO-STM32.uvprojx, settings and files
target GAME (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Lcd;..\..\User\Palette;..\..\User\JOYPAD;..\..\User\led;..\..\User\usart;..\..\User\SysTick;..\..\User\NES;..\..\User\NES\mapper;..\..\User\ExSRAM;..\..\User\MALLOC;..\..\ff10;..\..\User\TouchPad;..\..\User\vs1053;..\..\User\Key;..\..\User\spi_flash;..\..\ff10\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/Lcd/: bsp_ili9341_lcd.c
    ../../User/lcd/: bsp_xpt2046_lcd.c bsp_lcd.c
    ../../User/Palette/: palette.c
    ../../User/JOYPAD/: joypad.c
    ../../User/led/: bsp_led.c
    ../../User/usart/: bsp_usart1.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/ExSRAM/: bsp_fsmc_sram.c
    ../../User/MALLOC/: malloc.c
    ../../User/vs1053/: VS1053.c
    ../../User/spi_flash/: fatfs_flash_spi.c
    ../../User/TouchPad/: TouchPad.c
    ../../User/Key/: bsp_key.c
  group NES
    ../../User/NES/: nes_apu.c nes_main.c nes_mapper.c nes_ppu.c 6502.s cart.s
  group ff10
    ../../ff10/: diskio.c ff.c
    ../../ff10/option/: cc936.c
software components: CMSIS:CORE 4.1.0
