# Keil uVision project RA2L1_Project.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: R7FA2L1AB Renesas
  pack: Renesas.RA_DFP.4.4.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: RA2L1_Project +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\src;.\qe_gen
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
    ./src/debug_uart/: bsp_debug_uart.c bsp_debug_uart.h
    ./src/key/: bsp_key.c bsp_key.h
    ./src/led/: bsp_led.c bsp_led.h
  group CTSU
    ./qe_gen/: qe_touch_config.c qe_touch_sample.c
software components: Flex Software:RA Configuration 1.0.0
